# Keil uVision project testFinal.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LM3S9B92 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00018000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: testFinal
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: PART_LM3S9B92
  c include: ..\AlgoCarto\lib\StellarisWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Startup.s main.c capteur.c motor_my.c message.c
    ../AlgoCarto/lib/StellarisWare/driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../AlgoCarto/lib/StellarisWare/boards/ek-evalbot/drivers/: sensors.c motor.c
