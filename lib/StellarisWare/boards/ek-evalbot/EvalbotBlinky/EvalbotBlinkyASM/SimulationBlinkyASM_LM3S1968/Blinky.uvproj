# Keil uVision project Blinky.uvproj, settings and files
target LM3S1968 Flash (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group StartUp
    ./: Startup.s
  group Source Files
    ./: main.s
  group Documentation
    ./: Abstract.txt
