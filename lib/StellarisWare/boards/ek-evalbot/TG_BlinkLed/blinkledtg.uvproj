# Keil uVision project blinkledtg.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: blinkledtg
  c flags: Optim=1
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Startup.s blink.c
