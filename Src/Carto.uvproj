# Keil uVision project Carto.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Carto
  c flags: Optim=3
  c define: PART_LM3S9B92 NO_SERVEUR_DEF
  c include: ..\lib\StellarisWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Startup.s main.c carto.c Xbee_Protoc.c
    ../lib/StellarisWare/driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../lib/StellarisWare/boards/ek-evalbot/drivers/: io.c motor.c sensors.c
